options:
  parameters:
    generate_options: qt_gui
    id: record_nfc
    output_language: python
    title: record nfc with rtl-sdr
  states: {}

blocks:
- name: const
  id: variable_qtgui_range
  parameters:
    start: '-1'
    step: '0.1'
    stop: '0'
    value: '0'
  states: {}
- name: cutoff_freq
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: 10e2
    stop: samp_rate/2
    value: subport/2
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: (nfc_freq-1.8e6)
    step: 1e2
    stop: (nfc_freq+1.8e6*2)
    value: nfc_freq
  states: {}
- name: high_freq
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: 1e3
    stop: samp_rate/2
    value: samp_rate/2
  states: {}
- name: low_freq
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: 1e3
    stop: samp_rate/2
    value: '1'
  states: {}
- name: nfc_freq
  id: variable
  parameters:
    value: +13.56e6
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '50'
    value: '49.6'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.8e6
  states: {}
- name: subport
  id: variable
  parameters:
    value: 847.5e3
  states: {}
- name: transition_width
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: 500e3
    value: 10e3
  states: {}
- name: upconverter
  id: variable
  parameters:
    value: 125e6
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/luca/github/university/nfc-unipd/data/gqrx_fixed/ground-sending.raw
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: 1024*5
    srate: samp_rate
    type: float
    ymax: '2'
    ymin: '-0.3'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '41'
    interp: '1'
    taps: ''
    type: fff
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    alias: rtl_sdr
    args: '"rtl=0,direct_samp=2"'
    bb_gain0: '0'
    comment: |-
      ON RT820
      bandwidth must be implemented and should be fore tuner (used on hackrf only), 
      if_gain and bb_gain does not exist

      direct_samp=2 - Q-samples
      max rf 49.6




      Try:
      rtl_xtal=28.81e6
      rtl_xtal=28.79e6
    freq0: freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_complex_to_float_1, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_1, '0']
- [rtlsdr_source_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-104-g8ccb8e65
